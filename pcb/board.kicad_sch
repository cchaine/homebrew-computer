File: pcb/board.kicad_sch (KiCad schematic)
At the start: 2 parts

Commit message: change to lx9 and reduce power
Other:
- sheet DRAM renamed SRAM
- sheet SRAM: file dram.kicad_sch -> sram.kicad_sch
