File: pcb/memory.kicad_sch (KiCad schematic)
At the start: 4 parts

Commit message: start adding processor fpga
